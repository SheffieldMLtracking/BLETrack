# Keil uVision project blinky.uvprojx, settings and files
target DA14585 (6220000::V6.22::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: blinky_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __NON_BLE_EXAMPLE__
  c misc: -mthumb -c
  c include: .\..\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\..\sdk\ble_stack\ea\api;.\..\..\..\..\..\..\sdk\ble_stack\em\api;.\..\..\..\..\..\..\sdk\ble_stack\hci\api;.\..\..\..\..\..\..\sdk\ble_stack\hci\src;.\..\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anc\ancc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anp\anpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anp\anps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bas\basc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bcs;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\blp\blpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\blp\blps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bms;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bms\bmsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bms\bmss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cppc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cpps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cts;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cts\ctsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cts\ctss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\..\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\dis\disc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\find;.\..\..\..\..\..\..\sdk\ble_stack\profiles\find\findl\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\find\findt\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\gatt\gatt_client\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\glp\glpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\glp\glps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpbh\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogprh\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpt\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\..\sdk\ble_stack\profiles\lan\lanc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\lan\lans\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\pasp\paspc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\pasp\pasps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxm\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scppc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scpps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\..\sdk\ble_stack\profiles\tip\tipc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\tip\tips\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\..\sdk\ble_stack\profiles\uds\udsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\uds\udss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\wss;.\..\..\..\..\..\..\sdk\ble_stack\profiles\wss\wssc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\wss\wsss\api;.\..\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\..\sdk\platform\arch\boot;.\..\..\..\..\..\..\sdk\platform\arch\boot\ARM;.\..\..\..\..\..\..\sdk\platform\arch\boot\GCC;.\..\..\..\..\..\..\sdk\platform\arch\compiler;.\..\..\..\..\..\..\sdk\platform\arch\compiler\ARM;.\..\..\..\..\..\..\sdk\platform\arch\compiler\GCC;.\..\..\..\..\..\..\sdk\platform\arch\ll;.\..\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\..\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\..\sdk\platform\driver\ble;.\..\..\..\..\..\..\sdk\platform\driver\dma;.\..\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\..\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\..\sdk\platform\driver\i2c;.\..\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\..\sdk\platform\driver\pdm;.\..\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\..\sdk\platform\driver\rtc;.\..\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\..\sdk\platform\driver\spi_hci;.\..\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\..\sdk\platform\driver\timer;.\..\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\..\sdk\platform\system_library\include;.\..\..\..\..\..\..\third_party\hash;.\..\..\..\..\..\..\third_party\rand;.\..\include;.\..\..\..\shared\api;..\..\..\..\..\..\sdk\platform\utilities\otp_hdr;..\..\..\..\..\..\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include
  library: MicroLIB
  scatter file: ..\..\..\shared\peripheral_examples_armclang.sct
  link misc: --userlibpath ..\..\..\..\..\..\sdk\platform\system_library\output\Keil_5\ da14585_586.lib
  group sdk_boot
    ../../../../../../sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c system_DA14535.c
    ../../../../../../sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s startup_DA14535.s
    ../../../shared/source/: exceptions.c
  group sdk_arch
    ../../../../../../sdk/platform/arch/main/: arch_system.c
  group sdk_driver
    ../../../../../../sdk/platform/driver/syscntl/: syscntl.c
    ../../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../../sdk/platform/driver/uart/: uart.c uart_utils.c
    ../../../../../../sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ../../../../../../sdk/platform/utilities/otp_cs/: otp_cs.c
    ../../../../../../sdk/platform/driver/spi_flash/: spi_flash.c
    ../../../../../../sdk/platform/driver/spi/: spi_58x.c
    ../../../../../../sdk/platform/driver/i2c/: i2c.c
    ../../../../../../sdk/platform/driver/rtc/: rtc.c
  group user_app
    ../src/: main.c user_periph_setup.c
target DA14586 (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: blinky_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14586__ __NON_BLE_EXAMPLE__
  c misc: -mthumb -c
  c include: as above
  library: MicroLIB
  scatter file: ..\..\..\shared\peripheral_examples_armclang.sct
  link misc: as above
target DA14531 (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: blinky_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ __NON_BLE_EXAMPLE__
  c misc: -mthumb -c
  c include: .\..\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\..\sdk\ble_stack\ea\api;.\..\..\..\..\..\..\sdk\ble_stack\em\api;.\..\..\..\..\..\..\sdk\ble_stack\hci\api;.\..\..\..\..\..\..\sdk\ble_stack\hci\src;.\..\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anc\ancc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anp\anpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anp\anps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bas\basc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bcs;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\blp\blpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\blp\blps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bms;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bms\bmsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bms\bmss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cppc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cpps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cts;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cts\ctsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cts\ctss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\..\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\dis\disc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\find;.\..\..\..\..\..\..\sdk\ble_stack\profiles\find\findl\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\find\findt\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\gatt\gatt_client\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\glp\glpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\glp\glps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpbh\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogprh\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpt\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\..\sdk\ble_stack\profiles\lan\lanc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\lan\lans\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\pasp\paspc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\pasp\pasps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxm\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scppc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scpps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\..\sdk\ble_stack\profiles\tip\tipc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\tip\tips\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\..\sdk\ble_stack\profiles\uds\udsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\uds\udss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\wss;.\..\..\..\..\..\..\sdk\ble_stack\profiles\wss\wssc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\wss\wsss\api;.\..\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\..\sdk\platform\arch\boot;.\..\..\..\..\..\..\sdk\platform\arch\boot\ARM;.\..\..\..\..\..\..\sdk\platform\arch\boot\GCC;.\..\..\..\..\..\..\sdk\platform\arch\compiler;.\..\..\..\..\..\..\sdk\platform\arch\compiler\ARM;.\..\..\..\..\..\..\sdk\platform\arch\compiler\GCC;.\..\..\..\..\..\..\sdk\platform\arch\ll;.\..\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\..\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\..\sdk\platform\driver\ble;.\..\..\..\..\..\..\sdk\platform\driver\dma;.\..\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\..\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\..\sdk\platform\driver\i2c;.\..\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\..\sdk\platform\driver\pdm;.\..\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\..\sdk\platform\driver\rtc;.\..\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\..\sdk\platform\driver\spi_hci;.\..\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\..\sdk\platform\driver\timer;.\..\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\..\sdk\platform\system_library\include;.\..\..\..\..\..\..\third_party\hash;.\..\..\..\..\..\..\third_party\rand;.\..\include;.\..\..\..\shared\api;..\..\..\..\..\..\sdk\platform\utilities\otp_hdr;..\..\..\..\..\..\sdk\platform\utilities\otp_cs;..\..\..\..\..\..\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\shared\peripheral_examples_armclang.sct
  link misc: --userlibpath ..\..\..\..\..\..\sdk\platform\system_library\output\Keil_5\ da14531.lib
target DA14531_01 (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: blinky_531_01 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531_01\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ __DA14531_01__ __NON_BLE_EXAMPLE__
  c misc: -mthumb -c
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\shared\peripheral_examples_armclang.sct
  link misc: .\..\..\..\..\..\..\sdk\common_project_files\misc\da14531_01_for_periph.txt
--userlibpath ..\..\..\..\..\..\sdk\platform\system_library\output\Keil_5\ da14531_01.lib
target DA14535 (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: blinky_535 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14535\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ __DA14535__ __NON_BLE_EXAMPLE__
  c misc: -mthumb -c
  c include: .\..\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\..\sdk\ble_stack\ea\api;.\..\..\..\..\..\..\sdk\ble_stack\em\api;.\..\..\..\..\..\..\sdk\ble_stack\hci\api;.\..\..\..\..\..\..\sdk\ble_stack\hci\src;.\..\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anc\ancc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anp\anpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\anp\anps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bas\basc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bcs;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\blp\blpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\blp\blps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bms;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bms\bmsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\bms\bmss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cppc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cpps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cts;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cts\ctsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\cts\ctss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\..\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\dis\disc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\find;.\..\..\..\..\..\..\sdk\ble_stack\profiles\find\findl\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\find\findt\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\gatt\gatt_client\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\glp\glpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\glp\glps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpbh\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogprh\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpt\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\..\sdk\ble_stack\profiles\lan\lanc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\lan\lans\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\pasp\paspc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\pasp\pasps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxm\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscpc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scppc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scpps\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\..\sdk\ble_stack\profiles\tip\tipc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\tip\tips\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\..\sdk\ble_stack\profiles\uds\udsc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\uds\udss\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\wss;.\..\..\..\..\..\..\sdk\ble_stack\profiles\wss\wssc\api;.\..\..\..\..\..\..\sdk\ble_stack\profiles\wss\wsss\api;.\..\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\..\sdk\platform\arch\boot;.\..\..\..\..\..\..\sdk\platform\arch\boot\ARM;.\..\..\..\..\..\..\sdk\platform\arch\boot\GCC;.\..\..\..\..\..\..\sdk\platform\arch\compiler;.\..\..\..\..\..\..\sdk\platform\arch\compiler\ARM;.\..\..\..\..\..\..\sdk\platform\arch\compiler\GCC;.\..\..\..\..\..\..\sdk\platform\arch\ll;.\..\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\..\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\..\sdk\platform\driver\ble;.\..\..\..\..\..\..\sdk\platform\driver\dma;.\..\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\..\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\..\sdk\platform\driver\i2c;.\..\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\..\sdk\platform\driver\pdm;.\..\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\..\sdk\platform\driver\rtc;.\..\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\..\sdk\platform\driver\spi_hci;.\..\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\..\sdk\platform\driver\timer;.\..\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\..\sdk\platform\system_library\include;.\..\..\..\..\..\..\third_party\hash;.\..\..\..\..\..\..\third_party\rand;.\..\include;.\..\..\..\shared\api;..\..\..\..\..\..\sdk\platform\utilities\otp_hdr;..\..\..\..\..\..\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;..\..\..\..\..\..\sdk\platform\utilities\otp_cs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\shared\peripheral_examples_armclang.sct
  link misc: .\..\..\..\..\..\..\sdk\common_project_files\misc\da14535_for_periph.txt
--userlibpath ..\..\..\..\..\..\sdk\platform\system_library\output\Keil_5\ da14535.lib
